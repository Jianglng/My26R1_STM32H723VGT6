# Keil uVision project My26R1_STM32H723VGT6.uvprojx, settings and files
target My26R1_STM32H723VGT6 (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: My26R1_STM32H723VGT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c misc: -Wall -Wextra
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Drivers/CMSIS/RTOS2/Include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../task;../bsp;../protocol/vesc;../protocol/dji;../protocol/remote;../protocol/imu;../protocol/lidar;../localization;../control/manual;../control/auto;../algorithm/trajectory;../algorithm/kinematics;../algorithm/pid;../algorithm/math;../chassis;../common;../robot_config;../debug
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Task
    ../task/: chassis_task.cpp chassis_app.cpp chassis_app.h chassis_task.h
  group bsp
    ../bsp/: bsp_can.cpp bsp_can.h bsp_critical.h bsp_dwt.cpp bsp_dwt.h bsp_uart.cpp bsp_uart.h bsp_usb.cpp bsp_usb.h
  group protocol/vesc
    ../protocol/vesc/: vesc_motor.cpp vesc_motor.h
  group protocol/dji
    ../protocol/dji/: dji_6020.cpp dji_6020.h
  group protocol/remote
    ../protocol/remote/: remote_input.cpp remote_input.h
  group protocol/imu
    ../protocol/imu/: chaohe_imu.cpp chaohe_imu.h hipnuc_dec.c hipnuc_dec.h hipnuc_sample.c hipnuc_sample.h
  group protocol/lidar
    ../protocol/lidar/: lidar_pose_protocol.cpp lidar_pose_protocol.h
  group localization
    ../localization/: chassis_odometry.cpp chassis_odometry.h lidar_localization.cpp lidar_localization.h pose_source.cpp pose_source.h
  group control/manual
    ../control/manual/: manual_mode_controller.cpp manual_mode_controller.h
  group control/auto
    ../control/auto/: auto_mode_controller.cpp auto_mode_controller.h auto_move.cpp auto_move.h
  group algorithm/trajectory
    ../algorithm/trajectory/: trapezoidal_profile.cpp trapezoidal_profile.h auto_move_params.h
  group algorithm/kinematics
    ../algorithm/kinematics/: chassis_kinematics.cpp chassis_kinematics.h
  group algorithm/pid
    ../algorithm/pid/: pid.cpp pid.h
  group algorithm/math
    ../algorithm/math/: math_utils.h
  group chassis
    ../chassis/: chassis.cpp chassis.h
  group common
    ../common/: motion_types.h
  group robot_config
    ../robot_config/: auto_move_config.h auto_route_config.h localization_config.h robot_config.h tune_params.cpp tune_params.h
  group debug
    ../debug/: debug_snapshot.cpp debug_snapshot.h
software components: CMSIS:CORE 6.1.1
